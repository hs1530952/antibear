# Keil uVision project antiBear.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: antiBear +hex
  AfterMake: .\hexGenerator.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG USE_HAL_DRIVER USE_FULL_LL_DRIVER
  c misc: -Wdouble-promotion -Wold-style-definition -fdata-sections -fno-common -pipe -MP
  c include: ..\lib\main\CMSIS\Core\Include;..\lib\main\STM32H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\src\keil;..\src\keil\startup;..\src\keil\build;..\src\keil\system;..\src\keil\scheduler;..\src\keil\drivers;..\src\keil\drivers\mcu
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0x4000000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/STM32H7xx_HAL_Driver
    ../lib/main/STM32H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group main
    ../src/keil/: main.c
  group main/startup
    ../src/keil/startup/arm/: startup_stm32h743xx.s
    ../src/keil/startup/: system_stm32h7xx.c
  group main/system
    ../src/keil/system/: init.c tasks.c
  group main/scheduler
    ../src/keil/scheduler/: scheduler.c
  group main/build
    ../src/keil/build/: debugSerial.c
  group main/drivers
    ../src/keil/drivers/: system.c uart.c i2c_utils.c i2c_timing.c
  group main/drivers/mcu
    ../src/keil/drivers/mcu/: system_stm32h7xx.c stm32h7xx_hal_timebase_tim.c memprot_hal.c io.c uart_hal.c i2c_hal.c
  group main/drivers/eeprom
    ../src/keil/drivers/eeprom/: eeprom.c eeprom_at24c02.c
target Release (6220000::V6.22::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: antiBear +hex
  AfterMake: .\hexGenerator.bat
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER USE_FULL_LL_DRIVER
  c misc: -Wdouble-promotion -Wold-style-definition -fdata-sections -fno-common -pipe -MP -Werror -ffast-math -fmerge-all-constants
  c include: ..\lib\main\CMSIS\Core\Include;..\lib\main\STM32H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\src\keil;..\src\keil\startup;..\src\keil\build;..\src\keil\drivers;..\src\keil\drivers\mcu
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\src\link\stm32_flash_h743_2m.sct
